options:
  parameters:
    author: yue
    generate_options: qt_gui
    id: GMSK_Receiver
    output_language: python
    title: GMSK Receiver
  states: {}

blocks:
- name: B210
  id: variable
  parameters:
    value: '"serial= 31B1A79"'
  states: {}
- name: N210
  id: variable
  parameters:
    value: '"addr=192.168.10.3"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: const
  id: variable_qtgui_range
  parameters:
    label: Constellation Const
    start: '1'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: pkt_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: receiver_gain
  id: variable_qtgui_range
  parameters:
    label: Receiver Gain
    start: '0'
    step: '1'
    stop: '76'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /mnt/c/Users/billi/OneDrive/Documents/workarea/my_work/gnuradio/GMSK/out.txt
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: const
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: len_key
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    tagname: len_key
    threshold: '0'
    type: byte
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: len_key
    packed: 'False'
  states: {state: bypassed}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: sps
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\n\nimport numpy as np\nfrom gnuradio import gr\nimport time\n\n\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n   \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n\n   def __init__(self, default_parameters = 0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Print Message',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=None\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.dr_start_time = None\n        self.dr_count_packet = None\n        #Initialize Timer\n        self.dr_start_time = time.time()\n        self.dr_count_packet = 0\n\n\n   def work(self, input_items, output_items):\n        \"\"\"example: multiply with constant\"\"\"\n        for data in input_items[0]:\n            # print(data)\n            # try:\n            #     print(chr(data),end='')\n            # except:\n            #     pass\n            self.dr_count_packet += 1\n            if time.time() - self.dr_start_time >= 1:\n                #print(\"data rate:\", self.dr_count_packet*8/(time.time() - self.dr_start_time)/1000,'kbps')\n                print(self.dr_count_packet*8/(time.time() - self.dr_start_time)/1000)\n                self.dr_count_packet = 0\n                self.dr_start_time = time.time()\n        # print(input_items[0][:])\n        # output_items[0][:] = input_items[0] * self.example_param\n        return len(input_items[0])\n\n\n\n\n"
    default_parameters: '1'
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    label1: channel in
    name: channel
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '8192'
    gui_hint: 0,0,1,1
    label1: channel in
    name: channel
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 2,0,1,1
    label1: sender
    name: '"File input"'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '150'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: 2,1,1,1
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: N210
    dev_args: '""'
    gain0: receiver_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: file_in
  states: {}
- name: virtual_sink_3_0
  id: virtual_sink
  parameters:
    stream_id: channel out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: file_in
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: channel out
  states: {}
- name: virtual_source_3_0_0
  id: virtual_source
  parameters:
    stream_id: channel out
  states: {}
- name: virtual_source_3_0_0_0
  id: virtual_source
  parameters:
    stream_id: channel out
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_3_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_crc32_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_0, '0', epy_block_1, '0']
- [digital_crc32_bb_0, '0', virtual_sink_0_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_gmsk_demod_0, '0', digital_diff_decoder_bb_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_3_0, '0', digital_gmsk_demod_0, '0']
- [virtual_source_3_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_3_0_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_3_0_0_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
