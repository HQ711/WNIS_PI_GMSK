options:
  parameters:
    author: yue
    generate_options: qt_gui
    id: GMSK_Sender
    output_language: python
    title: GMSK Sender
  states: {}

blocks:
- name: B210
  id: variable
  parameters:
    value: '"serial= 31B1A69"'
  states: {}
- name: N210
  id: variable
  parameters:
    value: '"addr=192.168.10.2"'
  states: {}
- name: bandwidth
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: const
  id: variable_qtgui_range
  parameters:
    label: Const
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.05'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: pkt_len
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sender_gain
  id: variable_qtgui_range
  parameters:
    label: Transmitter Gain
    start: '0'
    step: '1'
    stop: '89.8'
    value: '0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '2'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /mnt/c/Users/billi/OneDrive/Documents/workarea/my_work/gnuradio/ALOHA/bigfile.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: const
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_key
    packet_len: pkt_len
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: len_key
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: len_key
    packed: 'False'
  states: {state: bypassed}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: len_key
  states: {}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,1,1,1
    label1: channel in
    name: channel
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: bandwidth
    ctrlpanel: 'True'
    fc: center_freq
    fftsize: '8192'
    gui_hint: 0,0,1,1
    label: Relative gain
    label1: channel in
    name: channel
    type: complex
    update_time: '0.01'
    wintype: window.WIN_HAMMING
    ymax: '50'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    gui_hint: 2,0,1,1
    label1: sender
    name: '"File input"'
    size: '256'
    srate: samp_rate
    type: float
    ymax: '150'
    ymin: '0'
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    center_freq: center_freq
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: N210
    gain0: sender_gain
    samp_rate: 'samp_rate '
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: file_out1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: channel in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: file_out1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: channel in
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: channel in
  states: {}

connections:
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', uhd_usrp_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_gmsk_mod_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', virtual_sink_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_diff_encoder_bb_0, '0']
- [digital_crc32_bb_0, '0', blocks_tagged_stream_mux_0, '1']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_diff_encoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gmsk_mod_0, '0', virtual_sink_3, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_0_0, '0']
- [virtual_source_3, '0', blocks_multiply_const_vxx_1_0, '0']
- [virtual_source_3_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_3_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
